# Keil uVision project Gen_47-release.uvprojx, settings and files
target Generator (6140001::V6.14.1::ARMCLANG)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gen-release +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32G030xx RELEASE
  c include: .\CMSIS;.\Starup;.\User;.\CMSIS\inc;.\User\inc;.\ugfx_2.9\src\gdisp;.\ugfx_2.9\src;.\ugfx_2.9;.\ugfx_2.9\src\gos;.\ugfx_2.9\src\gwin;.\ugfx_2.9\drivers\gdisp\ILI9341;.\ugfx_2.9\src\ginput;.\ugfx_2.9\drivers\ginput\toggle\Pal;.\Display;.\ugfx_2.9\drivers\ginput\touch\FT6x06;.\DriversCommon;.\PowerModes;.\W25QXX;.\Communications;.\Player;.\acc;.\PowerModes
  memory RVCT4: ROM 0x8001800 size 0xd800
  memory RVCT9: RAM 0x20000100 size 0x1f00
  scatter file: .\gen_47-release.sct
  group CMSIS
    ./CMSIS/src/: system_stm32g0xx.c
  group Startup
    ./Starup/: startup_stm32g030xx.s
  group Main
    ./User/src/: BoardSetup.c main.c
    ./ugfx_2.9/drivers/gdisp/ILI9341/: board_ILI9341.h
    ./ugfx_2.9/: gfxconf.h
  group ugfx
    ./ugfx_2.9/drivers/gdisp/ILI9341/: gdisp_lld_ILI9341.c
    ./ugfx_2.9/src/: gfx_mk.c
    ./ugfx_2.9/drivers/ginput/touch/FT6x06/: gmouse_lld_FT6x06.c
  group Display
    ./Display/: superloopDisplay.c
  group DriversCommon
    ./DriversCommon/: i2c2.c Spi1.c
  group Communications
    ./Communications/: SuperLoop_Comm.c
  group W25qxx
    ./W25QXX/: w25qxx.c
  group Player
    ./Player/: SuperLoop_Player.c
  group ACC
    ./acc/: battery.c DriverBQ28z610.c DRIVERBQ25703.c DriverTPS65982_6.c i2c_API.c i2c1.c mainFSM.c regBQ25703A.c superloop_ACC.c I2C_COMMON.c
  group PowerModes
    ./PowerModes/: board_PowerModes.c
